# Keil uVision project Project.uvprojx, settings and files
target STM320518-EVAL-CONFIG1 (ARM-ADS)
  device: STM32F051C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM320518-EVAL-CONFIG1
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM320518_EVAL,STM32F0XX,STM320518_EVAL_REVB,STM320518_EVAL_DEMO_CONFIG1
  c include: .\..\inc;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\..\..\..\Libraries\CMSIS\Include;.\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\Utilities\Third_Party\FatFs_vR0.08a;.\..\..\..\Utilities\STM32_EVAL;.\..\..\..\Utilities\STM32_EVAL\Common;.\..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../src/: system_stm32f0xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group FatFs
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_cec.c stm320518_eval_i2c_ee.c stm320518_eval_i2c_tsensor.c stm320518_eval_lcd.c stm320518_eval_spi_sd.c
  group User
    ../src/: about.c applications.c calendar.c cec_display.c diskio.c help.c lowpower.c main.c menu.c rc5_decode.c rc5_encode.c rf_eeprom.c sirc_decode.c sirc_encode.c stm32f0xx_it.c storage.c thermometer.c waveplayer.c waverecord.c
target STM320518-EVAL-CONFIG2 (ARM-ADS)
  device: STM32F051C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: as above
  output: STM320518-EVAL-CONFIG2
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM320518_EVAL,STM32F0XX,STM320518_EVAL_REVB,STM320518_EVAL_DEMO_CONFIG2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 4.3.0
