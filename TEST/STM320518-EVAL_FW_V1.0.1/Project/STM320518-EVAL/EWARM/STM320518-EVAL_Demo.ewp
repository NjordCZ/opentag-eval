# IAR project STM320518-EVAL_Demo.ewp, settings and files
configuration STM320518-EVAL-CONFIG1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM320518_EVAL; STM32F0XX; STM320518_EVAL_REVB; STM320518_EVAL_DEMO_CONFIG1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Utilities\Third_Party\FatFs_vR0.08a; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm320518-eval_fw_v1.0.1_config1.hex
  ILINK.IlinkOutputFile: STM32F0518-EVAL.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM320518-EVAL-CONFIG2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM320518_EVAL; STM32F0XX; STM320518_EVAL_REVB; STM320518_EVAL_DEMO_CONFIG2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm320518-eval_fw_v1.0.1_config2.hex
configuration GUN (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM320518_EVAL; STM32F0XX; STM320518_EVAL_REVB; STM320518_EVAL_DEMO_CONFIG2; GUN
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm320518-eval_fw_v1.0.1_config2.hex
configuration HEADBAND (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm320518-eval_fw_v1.0.1_config2.hex
configuration ADMIN (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm320518-eval_fw_v1.0.1_config2.hex
configuration BOX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm320518-eval_fw_v1.0.1_config2.hex
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group EWARM
    ./: startup_stm32f0xx.s
  group FatFs
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_cec.c stm320518_eval_i2c_ee.c stm320518_eval_i2c_tsensor.c stm320518_eval_spi_sd.c
  group User
    ../src/: bluetooth.c diskio.c HD44780LIB.c i2c_ssd1306.c io.c ir_lasertag.c lasertag.c lcd_fonts.c main.c stm32f0xx_it.c storage.c time_date.c waveplayer.c
