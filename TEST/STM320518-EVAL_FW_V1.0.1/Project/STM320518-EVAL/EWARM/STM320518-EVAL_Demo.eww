<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM320518-EVAL_Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


